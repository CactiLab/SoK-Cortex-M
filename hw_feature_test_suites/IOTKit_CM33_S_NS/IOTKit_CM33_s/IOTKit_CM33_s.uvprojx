# Keil uVision project IOTKit_CM33_s.uvprojx, settings and files
target V2M-MPS2+ (6150000::V6.15::ARMCLANG)
  device: IOTKit_CM33_FP ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.4.2
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28200000,0x00200000) IROM(0x10000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: IOTKit_CM33_s
  c flags: Optim=7 v6Lang=5
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  link misc: --show_parent_lib --show_full_path
  group Source Group 1
    ./: main_s.c stdout_USART.c test_s.c test_s.h test_case_s.c
  group Documentation
    ../: Abstract.txt
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Common 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, CMSIS Driver:USART 1.0.0, Device:Startup 1.0.3
