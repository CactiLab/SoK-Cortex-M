# Keil uVision project CM3_Blinky.uvprojx, settings and files
target Simulator (6150000::V6.15::ARMCLANG)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.1
  cpu: IROM(0x00000000,0x400000) IRAM(0x20000000,0x400000) CPUTYPE("Cortex-M3") CLOCK(25000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __USE_TIMER0 __USE_FPGA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  group Source Files
    ./: Blinky.c stdout_USART.c test.c test_cases.c test.h
  group Documentation
    ./: Abstract.txt
target FastModels (6140001::V6.14.1::ARMCLANG)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.1
  cpu: as above
  output: Blinky
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __USE_LCD __USE_TIMER0 __USE_FPGA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
target V2M-MPS2 (6150000::V6.15::ARMCLANG)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.1
  cpu: as above
  output: Blinky
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __USE_LCD __USE_TIMER0 __USE_FPGA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
target V2M-MPS2 SWO (6140001::V6.14.1::ARMCLANG)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.1
  cpu: as above
  output: Blinky
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __USE_LCD __USE_TIMER0 __USE_FPGA __DBG_ITM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
target V2M-MPS2 Trace (6140001::V6.14.1::ARMCLANG)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.1
  cpu: as above
  output: Blinky
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __USE_LCD __USE_TIMER0 __USE_FPGA __DBG_ITM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Buttons 2.0.0, Board Support:Common 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, Board Support:Touchscreen 2.0.0, CMSIS Driver:USART 1.0.3, Device:Startup 1.0.0
